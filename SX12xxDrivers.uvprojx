# Keil uVision project SX12xxDrivers.uvprojx, settings and files
target MasterModel (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SX12xxDrivers
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_XL MasterModel
  c include: .\src\platform;.\src\radio;.\src\platform\stm32libs\CMSIS\CM3;.\src\platform\sx12xxEiger;.\src\platform\stm32libs\STM32_USB-FS-Device_Driver\inc;.\src\platform\sx12xxEiger\Usb\stm32f10x\inc;.\src\platform\stm32libs\stm32f10x\inc;.\src\platform\stm32libs\STM32_USB-FS-Device_Driver\inc;.\src\platform\sx12xxEiger\Usb\stm32f10x\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./src/: main.c MasterModel.C SlaveModel.C
  group src\radio
    ./src/radio/: sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c radio.c
  group src\platform\sx12xxEiger
    ./src/platform/sx12xxEiger/: sx1276-Hal.c sx12xxEiger.c led.c spi.c i2c.c ioe.c fifo.c stm32fxxx_it.c sx1509.c uart.c
  group src\platform\stm32libs
    ./src/platform/stm32libs/stm32f10x/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./src/platform/stm32libs/CMSIS/CM3/: system_stm32f2xx.c system_stm32f10x.c system_stm32l1xx.c
    ./src/platform/stm32libs/stm32f10x/src/: startup_stm32f10x_xl.s startup_stm32f10x_xl_keil.s
  group platform\sx12xxEiger\Usb
    ./src/platform/sx12xxEiger/Usb/stm32f10x/src/: usb_bsp.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group src\platform\stm32libs\USB_CORE
    ./src/platform/stm32libs/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Document
    ./src/Document/: C语言printf()输出格式大全.txt note.txt readme.txt USB说明.txt 常用C语言标准库函数.txt 常用头文件.txt 笔记.txt 记录文件.txt
target SlaveModel (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: SX12xxDrivers
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_XL SlaveModel
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.1
